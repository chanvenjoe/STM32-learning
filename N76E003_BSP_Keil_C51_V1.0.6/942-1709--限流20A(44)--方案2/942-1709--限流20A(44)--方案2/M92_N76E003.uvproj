# Keil uVision project M92_N76E003.uvproj, settings and files
target M92_N76E003 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: 942 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group SOURCE
    ./SOURCE/: MAIN.c
