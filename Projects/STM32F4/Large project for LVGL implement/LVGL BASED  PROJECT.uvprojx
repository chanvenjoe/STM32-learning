# Keil uVision project LVGL BASED  PROJECT.uvprojx, settings and files
target Learning (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LVGL based projct +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\USER;.\FUNCTIONS\inc;.\LVGL;.\LVGL\lvgl;.\LVGL\LV_Driver;.\LVGL\lvgl\examples;.\LVGL\GUI_APP;..\2，标准例程-库函数版本\实验28 触摸屏实验\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FUNCTIONS
    ./FUNCTIONS/delay/: delay.c
    ./FUNCTIONS/sys/: sys.c
    ./FUNCTIONS/usart/: usart.c
    ./FUNCTIONS/Init/: LCD_init.c gpio_init.c
  group GUI
    ./LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./LVGL/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ./LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ./LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ./LVGL/lvgl/src/extra/: lv_extra.c
    ./LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ./LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./LVGL/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./LVGL/LV_Driver/: lv_port_disp.c lv_port_indev.c
