# Keil uVision project 942 platform.uvproj, settings and files
target 942 Platform (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: 942 platform
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code\inc
  group Main
    ./: STARTUP.A51
    ./code/src/: main.c
  group Functions
    ./code/src/: ADC.c Error_Code.c Flag_Init.c Init_MCU.c Input_Scan.c Motor_Control.c PWM.c Common.c Delay.c
    ../942 PID/Code/: System_Init.c
