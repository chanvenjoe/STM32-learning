# Keil uVision project LED driver.uvproj, settings and files
target LED driver (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LED driver
  c flags: Optimize=5 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Source Group 1
    ./: main.c
  group Functions
    ../Common/: Common.c Delay.c
    ./Functions/: Motor_control.c WS2811.c
  group Startup
    ./: STARTUP.A51
