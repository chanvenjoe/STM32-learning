# Keil uVision project TIM_PWM.uvprojx, settings and files
target MM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\..\..\..\..\Device\MM32SPIN2xx_p_LIB\Include;..\..\..\..\..\Device\MM32SPIN2xx_p_LIB\Source\KEIL_StartAsm
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../USER/: main.c
  group STARTUP
    ../../../../../Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ../../../../../Device/MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group HALlib
    ../../../../../Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
