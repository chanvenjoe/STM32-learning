# IAR project ADC_DMA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PF MindMotion MM32SPIN27PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DEVICE; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\MM32SPIN2xx_p_LIB\Include; ..\..\..\..\..\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc; ..\..\..\..\..\Device\CMSIS\IAR_CORE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_DMA.srec
  ILINK.IlinkOutputFile: MM32.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32SPIN27PF.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HALlib
    ../../../../../Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group STARTUP
    ../../../../../Device/MM32SPIN2xx_p_LIB/Source/IAR_StartAsm/: startup_MM32SPIN2xx_p.s
    ../../../../../Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
  group USER
    ../USER/: main.c
