# IAR project STM32F4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; xVECT_TAB_SRAM
  ICCARM.CCIncludePath2: C:\Users\Daddy CHOU\Desktop\Git project\STM32-learning\Projects\Large project for LVGL implement\FWLIB\inc; C:\Users\Daddy CHOU\Desktop\Git project\STM32-learning\Projects\Large project for LVGL implement\FUNCTIONS\inc; C:\Users\Daddy CHOU\Desktop\Git project\STM32-learning\Projects\Large project for LVGL implement; C:\Users\Daddy CHOU\Desktop\Git project\STM32-learning\Projects\Large project for LVGL implement
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../USER/: stm32f4xx_it.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../FUNCTIONS/delay/: delay.c
    ../FUNCTIONS/led/: gpio_init.c
    ../FUNCTIONS/sys/: sys.c
    ../FUNCTIONS/usart/: usart.c
  group START_UP
    ../CORE/: startup_stm32f40_41xxx.s
  group USER
    ./: main.c
    ../USER/: system_stm32f4xx.c
