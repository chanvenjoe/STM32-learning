# Keil uVision project 36V 25.uvproj, settings and files
target ADC (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ADC_Bandgap +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Source Group 1
    ./Code/: ADC.C
  group Common
    ../Common/: Delay.c Common.c
    ./Code/: Motor_control.c
    ../LED strip driver/Functions/: WS2811.c
  group Startup
    ../Startup/: STARTUP.A51
