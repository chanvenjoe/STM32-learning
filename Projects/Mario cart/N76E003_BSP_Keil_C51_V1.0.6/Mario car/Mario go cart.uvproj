# Keil uVision project Mario go cart.uvproj, settings and files
target Mario go cart (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Mario go cart +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Main
    ./Code/: main.C
  group Common
    ../Common/: Delay.c Common.c
    ./Code/: Motor_control.c
  group Startup
    ../Startup/: STARTUP.A51
