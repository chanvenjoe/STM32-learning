# Keil uVision project 942 speed and sound driver.uvproj, settings and files
target ADC (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ADC_Bandgap +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: ADC.C
  group Common
    ./Code/: Motor_control.c Speed_display.c
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
