# Keil uVision project MM32SPIN160C_Demo.uvprojx, settings and files
target SPIN160C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32SPIN160C_Demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe    --bin -o  ..\OBJ\MM32SPIN160C_Demo.bin ..\MM32SPIN160C_Demo.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_5V
  c include: ..\MM32SPIN0x_q\Include;..\MM32SPIN0x_q\HAL_lib\inc;..\BSP\inc;..\SYSTEM\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../MM32SPIN0x_q/Source/: system_mm32spin0x_q.c
    ../MM32SPIN0x_q/Source/KEIL_StartAsm/: startup_mm32spin0x_q_keil.s
  group HAL_Lib
    ../MM32SPIN0x_q/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group BSP
    ../BSP/: hall.c key.c led.c pwm.c
  group SYSTEM
    ../SYSTEM/: sys.c systick.c uart.c
  group USER
    ../USER/: main.c
software components: CMSIS:CORE 5.4.0
