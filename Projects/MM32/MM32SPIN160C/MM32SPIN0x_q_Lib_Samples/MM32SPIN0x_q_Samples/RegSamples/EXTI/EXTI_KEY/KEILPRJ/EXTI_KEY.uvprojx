# Keil uVision project EXTI_KEY.uvprojx, settings and files
target MM32Series (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.7
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32SPIN0x_q\Include;..\..\..\..\..\Device\MM32SPIN0x_q\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group STARTUP
    ../../../../../Device/MM32SPIN0x_q/Source/: system_mm32spin0x_q.c
    ../../../../../Device/MM32SPIN0x_q/Source/KEIL_StartAsm/: startup_mm32spin0x_q_keil.s
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
