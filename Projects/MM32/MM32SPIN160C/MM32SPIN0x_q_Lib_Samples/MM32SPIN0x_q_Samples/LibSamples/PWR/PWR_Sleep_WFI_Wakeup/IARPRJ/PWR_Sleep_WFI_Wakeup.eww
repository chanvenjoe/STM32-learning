<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\PWR_Sleep_WFI_Wakeup.ewp</path>
	</project>
	<batchBuild />
</workspace>
