# IAR project ADC_TIM1Trig_DMA_SingleChan_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN05PF MindMotion MM32SPIN05PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32SPIN05PF; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED
  ICCARM.CCDiagSuppress: Pa082,Pa089
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32SPIN0x_q\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32SPIN0x_q\Include; ..\HARDWARE\ADC; ..\HARDWARE\LED; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART; ..\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STARTUP
    ../../../../../Device/MM32SPIN0x_q/Source/IAR_StartAsm/: startup_mm32spin0x_q_iar.s
    ../../../../../Device/MM32SPIN0x_q/Source/: system_mm32spin0x_q.c
  group HARDWARE
    ../HARDWARE/ADC/: adc_tim1trig_dma_multichanit.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HALlib
    ../../../../../Device/MM32SPIN0x_q/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
