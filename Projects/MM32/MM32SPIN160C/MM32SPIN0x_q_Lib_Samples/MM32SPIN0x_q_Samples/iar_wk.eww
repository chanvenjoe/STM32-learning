<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_Awdg\IARPRJ\ADC_Awdg.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_DMA_Interrupt\IARPRJ\ADC_DMA_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_DMA_MultiChan_Interrupt\IARPRJ\ADC_DMA_MultiChan_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_DMA_polling\IARPRJ\ADC_DMA_polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_DMA_TemperatureSensor\IARPRJ\ADC_DMA_TemperatureSensor.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_DMA_VrefSensor\IARPRJ\ADC_DMA_VrefSensor.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_ExtLinesTrigger\IARPRJ\ADC_ExtLinesTrigger.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_Interrupt\IARPRJ\ADC_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_Polling\IARPRJ\ADC_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\ADC\ADC_TIM1Trig_DMA_SingleChan_Interrupt\IARPRJ\ADC_TIM1Trig_DMA_SingleChan_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\COMP\COMP_CRV\IARPRJ\COMP_CRV.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\COMP\COMP_Interrupt\IARPRJ\COMP_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\COMP\COMP_Polling\IARPRJ\COMP_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\CRC\CRC_BasicExample\IARPRJ\CRC_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\DIV\DIV_Operation\IARPRJ\DIV_Operation.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\DMA\DMA_SRAMtoSRAM\IARPRJ\DMA_SRAMtoSRAM.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\EXTI\EXTI_KEY\IARPRJ\EXTI_KEY.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\FLASH\FLASH_Program\IARPRJ\FLASH_Program.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\FLASH\FLASH_SetReadProtect\IARPRJ\FLASH_SetReadProtect.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\FLASH\FLASH_SIM_EEPROM\IARPRJ\FLASH_SIM_EEPROM.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\GPIO\GPIO_Key\IARPRJ\GPIO_Key.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\GPIO\GPIO_Toggle\IARPRJ\GPIO_Toggle.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_EEPROM_DMA_Master_Interrupt\IARPRJ\I2C_EEPROM_DMA_Master_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_EEPROM_DMA_polling\IARPRJ\I2C_EEPROM_DMA_polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_EEPROM_Master_Interrupt\IARPRJ\I2C_EEPROM_Master_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_EEPROM_Polling\IARPRJ\I2C_EEPROM_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_GPIO_SIM_EEPROM\IARPRJ\I2C_GPIO_SIM_EEPROM.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_Slave_DMA_Interrupt\IARPRJ\I2C_Slave_DMA_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_Slave_DMA_Polling\IARPRJ\I2C_Slave_DMA_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_Slave_Interrupt\IARPRJ\I2C_Slave_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\I2C\I2C_Slave_Polling\IARPRJ\I2C_Slave_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\IWDG\IWDG_Reset\IARPRJ\IWDG_Reset.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_CurrentConsumption\IARPRJ\PWR_CurrentConsumption.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_PVD_Interruput\IARPRJ\PWR_PVD_Interruput.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_PVD_Polling\IARPRJ\PWR_PVD_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_Sleep_WFI_Wakeup\IARPRJ\PWR_Sleep_WFI_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_Standby_IWDG_Wakeup\IARPRJ\PWR_Standby_IWDG_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_Standby_PIN_Wakeup\IARPRJ\PWR_Standby_PIN_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\PWR\PWR_Stop_EXTI_GPIO_Wakeup\IARPRJ\PWR_Stop_EXTI_GPIO_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\RCC\RCC_CSR_Reset\IARPRJ\RCC_CSR_Reset.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\RCC\RCC_MCO\IARPRJ\RCC_MCO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_1_32Bit_Loop\IARPRJ\SPI_1_32Bit_Loop.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_DMA_Polling_LoopBack\IARPRJ\SPI_DMA_Polling_LoopBack.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_FLASH_DMA_Polling\IARPRJ\SPI_FLASH_DMA_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_FLASH_Interrupt\IARPRJ\SPI_Flash_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_FLASH_Polling\IARPRJ\SPI_Flash_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_FLASH_SoftNSS\IARPRJ\SPI_FLASH_SoftNSS.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_GPIO_SIM_ExSpiFlash\IARPRJ\SPI_GPIO_SIM_ExSpiFlash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_Slave_DMA_Interrupt\IARPRJ\SPI_Slave_DMA_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_Slave_DMA_Polling\IARPRJ\SPI_Slave_DMA_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_Slave_Interrupt\IARPRJ\SPI_Slave_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SPI\SPI_Slave_Polling\IARPRJ\SPI_Slave_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\SYSTICK\SYSTICK_System1msDelay\IARPRJ\SYSTICK_System1msDelay.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_6Steps\IARPRJ\TIM1_6Steps.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_7PWM_Outputs\IARPRJ\TIM1_7PWM_Outputs.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_BasicExample\IARPRJ\TIM1_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_CC1_Interrupt\IARPRJ\TIM1_CC1_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_Dma_Ccr3\IARPRJ\TIM1_Dma_Ccr3.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_DMA_UPData\IARPRJ\TIM1_DMA_UPData.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_Interrupt\IARPRJ\TIM1_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM1_Monopulse\IARPRJ\TIM1_Monopulse.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM2_BasicExample\IARPRJ\TIM2_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM3_PWM_Input\IARPRJ\TIM3_PWM_Input.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM3_PWM_Output\IARPRJ\TIM3_PWM_Output.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM_Sync_1Master2Slave\IARPRJ\TIM_Sync_1Master2Slave.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\TIM\TIM_Sync_Prescaler\IARPRJ\TIM_Sync_Prescaler.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_9Bit\IARPRJ\UART_9Bit.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_AutoBaudRateSoft\IARPRJ\UART_AutoBaudRateSoft.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_DMA_Interrupt\IARPRJ\UART_DMA_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_DMA_Polling\IARPRJ\UART_DMA_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Interrupt\IARPRJ\UART_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Polling\IARPRJ\UART_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Print_DMA\IARPRJ\UART_Print_DMA.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Print_Polling\IARPRJ\UART_Print_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Receive_DMA_Interrupt\IARPRJ\UART_Receive_DMA_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Receive_DMA_Polling\IARPRJ\UART_Receive_DMA_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_Tx_DMA_Interrupt_Rx_Interrupt\IARPRJ\UART_Tx_DMA_Interrupt_Rx_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\UART\UART_WakeUp\IARPRJ\UART_WakeUp.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\LibSamples\WWDG\WWDG_Reset\IARPRJ\WWDG_Reset.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\ADC\ADC_BasicExample\IARPRJ\ADC_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\COMP\COMP_Polling\IARPRJ\COMP_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\DIV\DIV_Operation\IARPRJ\DIV_Operation.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\DMA\DMA_M2M\IARPRJ\DMA_M2M.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\EXTI\EXTI_KEY\IARPRJ\EXTI_KEY.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\GPIO\GPIO_Key\IARPRJ\GPIO_Key.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\GPIO\GPIO_Toggle\IARPRJ\GPIO_Toggle.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\I2C\I2C_EEPROM_eMiniBoard\IARPRJ\I2C_EEPROM_eMiniBoard.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\I2C\I2C_EEPROM_MiniBoard\IARPRJ\I2C_EEPROM_MiniBoard.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\IWDG\IWDG_Reset\IARPRJ\IWDG_Reset.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\PWR\PWR_Standby\IARPRJ\PWR_Standby.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\RCC\RCC_MCO\IARPRJ\RCC_MCO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\SPI\SPI_FLASH_HardNSS\IARPRJ\SPI_FLASH_HardNSS.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\SPI\SPI_FLASH_SoftNSS\IARPRJ\SPI_FLASH_SoftNSS.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\SYSTICK\SYSTICK_System1msDelay\IARPRJ\SYSTICK_System1msDelay.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\TIM\TIM1_BasicExample\IARPRJ\TIM1_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\TIM\TIM2_BasicExample\IARPRJ\TIM2_BasicExample.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\TIM\TIM3_PWM_Output\IARPRJ\TIM3_PWM_Output.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\UART\UART_Print_DMA\IARPRJ\UART_Print_DMA.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\UART\UART_Print_Interrupt\IARPRJ\UART_Print_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\UART\UART_Print_Polling\IARPRJ\UART_Print_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\UART\UART_Receive_DMA\IARPRJ\UART_Receive_DMA.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\WFI\WFI_Sleep\IARPRJ\WFI_Sleep.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RegSamples\WWDG\WWDG_Reset\IARPRJ\WWDG_Reset.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>wk</name>
			<member>
				<project>ADC_Awdg</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_DMA_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_DMA_MultiChan_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_DMA_polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_DMA_TemperatureSensor</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_DMA_VrefSensor</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_ExtLinesTrigger</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_TIM1Trig_DMA_SingleChan_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>COMP_CRV</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>COMP_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>COMP_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>CRC_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>DIV_Operation</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>DMA_SRAMtoSRAM</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>EXTI_KEY</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_Program</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_SetReadProtect</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_SIM_EEPROM</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_Key</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_Toggle</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_DMA_Master_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_DMA_polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_Master_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_GPIO_SIM_EEPROM</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_DMA_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_DMA_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>IWDG_Reset</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_CurrentConsumption</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_PVD_Interruput</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_PVD_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Sleep_WFI_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Standby_IWDG_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Standby_PIN_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Stop_EXTI_GPIO_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>RCC_CSR_Reset</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>RCC_MCO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_1_32Bit_Loop</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_DMA_Polling_LoopBack</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_DMA_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_SoftNSS</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_GPIO_SIM_ExSpiFlash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_DMA_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_DMA_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SYSTICK_System1msDelay</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_6Steps</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_7PWM_Outputs</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_CC1_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_Dma_Ccr3</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_DMA_UPData</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_Monopulse</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM2_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_PWM_Input</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_PWM_Output</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM_Sync_1Master2Slave</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM_Sync_Prescaler</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_9Bit</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_AutoBaudRateSoft</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_DMA_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_DMA_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Print_DMA</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Print_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Receive_DMA_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Receive_DMA_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Tx_DMA_Interrupt_Rx_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_WakeUp</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>WWDG_Reset</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>COMP_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>DIV_Operation</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>DMA_M2M</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>EXTI_KEY</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_Key</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_Toggle</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_eMiniBoard</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_EEPROM_MiniBoard</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>IWDG_Reset</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Standby</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>RCC_MCO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_HardNSS</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_FLASH_SoftNSS</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SYSTICK_System1msDelay</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM2_BasicExample</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_PWM_Output</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Print_DMA</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Print_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Print_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UART_Receive_DMA</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>WFI_Sleep</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>WWDG_Reset</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
